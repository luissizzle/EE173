# Repository luissizzle/EE173

## KiCad design EE173/Summer/EE173_Lab4.kicad_pcb

Board: 2 copper layers, 55.9 x 43.2 mm, 24 parts (0 on the bottom side), 16 nets.

Parts:
C1, C2, C3, C4: C; C_0805_2012Metric
D1: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
D2: LED; LED_D5.0mm
J1, J2: Conn_01x02_Male; header_2_pins
J3: Test Line; Vertical_BNC_Connector
J4: OSC; BNC_Connector
JP1, JP2, JP3, JP4, JP5, JP6: Jumper; header_2_pins
R1, R2, R3, R5, R6, R7: R; R_0805_2012Metric
U1: 74HC00; SN74HC00DR
U2: L7806; L7806ABV

Connections:
+6V: C3.2, C4.2, R1.1, R3.2, U1.13, U1.14, U2.3
GND: C2.1, C3.1, C4.1, D2.1, J1.2, J2.2, J3.2, J4.2, JP2.1, JP3.1, R2.2, U1.7, U2.2
unnamed: C1.1, R1.2, R2.1, U1.9, U1.10
unnamed: C1.2, JP1.2, JP2.2
unnamed: C2.2, D1.1, U2.1
unnamed: D1.2, J2.1
unnamed: D2.2, R3.1
unnamed: J1.1, JP1.1
unnamed: J3.1, JP3.2, JP6.2, R5.1, R6.1, R7.1
unnamed: J4.1, R7.2
unnamed: JP4.1, JP5.1, JP6.1, U1.6
unnamed: JP4.2, R5.2
unnamed: JP5.2, R6.2
unnamed: U1.1, U1.8, U1.12
unnamed: U1.3, U1.4, U1.5
unnamed: U1.2, U1.11

## Commit log

2018-11-21 Added labels
2018-11-21 added stupid mofo gate
    yyasss
2018-11-21 Add stupid cap mofo
2018-11-21 inductor bois
    boi inductors
2018-11-25 Deleted components that were added as a test. Finished some wiring I had overlooked. Added an alternative pulse generator with NOR gates.
2018-11-25 Added the jumpers to investigate source reflections. Did not choose values for resistors yet
2018-11-25 Made the sheet bigger
2018-11-25 Added BNC connecter at the beginning. This is where we will connect the two microstrips in parallel for the bifurcated line
2018-11-25 The BNC connecter at the beginning was a huge mistake. The Bifurcated lines will be added from the other end (OSC connection in Lab 3). Instead I added a jumper at the source to choose between signal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
2018-11-26 FootPrints
    -Footprints
    -Began PCB Layout
    -Netlist
2018-11-27 pushed changes i finna delete
2018-11-27 Vertical Connector Footprint
    updated footprints
2018-11-27 short to one of the jumpers
2018-11-27 had to reread netlist for pcb
2018-11-27 test
2018-11-27 deleted microstrip, completed netlist
2018-11-27 Copied projects and made individual folder paths
2018-11-27 Fixed HC00 Footprint
2018-11-27 made header 2 pins
2018-11-27 Edited HC00 footprint
2018-11-27 fixed header 2 pins
2018-11-27 Made no changes
2018-11-27 Redid BNC horizontal connector. Updated netlist.
2018-11-27 Updated BNC_Connector pins
2018-11-27 Vertical BNC Footprint
2018-11-27 Refixed Vertical BNC Connector
2018-11-27 worked on layout
2018-11-28 Finished layout. Changed VCC to 6V.
2018-11-28 Not new added
2018-11-28 Complete layout. Just need to finalize microstrip length
2018-11-28 progress on layout
2018-11-29 added new HC00 Footprint under digikey.pretty
2018-11-29 nothing changed
2018-11-29 Finished Layout
2018-11-29 updated header 2 pins
2018-11-29 Nothing New
2018-11-29 pushed to pull. no changes
2018-11-29 header 2 pins hole size to 1.02mm
2018-12-14 Changed Schematic
    Put all three circuits in the same schematic and added coax connectors

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
